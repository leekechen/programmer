# Keil uVision project bootloader.uvprojx, settings and files
target Flash_0x08000000 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BOOTLOADER
  c include: ..\..\src\drivers\bsp;..\..\src\drivers\dbg;..\..\src\common;..\..\src\bootloader;..\..\src\middlewave\files;..\..\src\drivers\spi_flash;..\..\src\drivers\lcd;..\..\src\drivers\fram;..\..\src\middlewave\crc;..\..\src\middlewave\program;..\..\..\trunk;..\..\src\middlewave\emWin\inc;..\..\src\middlewave\emWin\Config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\bootloader.sct
  group bootloader
    ../../src/bootloader/: bootloader.c gui_main.c
  group common
    ../../src/common/: error.c cswrite_cfg.c cswrite_log.c tlv.c
  group drivers/bsp
    ../../src/drivers/bsp/: crc32.c embed_flash.c retarget.c buzzer.c delay.c i2c_sw.c key.c led.c stm32f4xx_ll_gpio.c vs.c
  group drivers/dbg
    ../../src/drivers/dbg/: dbg_print.c
  group drivers/spi_flash
    ../../src/drivers/spi_flash/: w25qxx.c spi_flash.c
  group drivers/fram
    ../../src/drivers/fram/: fram_map.c mb85rcxx.c
  group drivers/lcd
    ../../src/drivers/lcd/: st7789v.c
  group middlewave/files
    ../../src/middlewave/files/: file_cfg.c file_dev.c file_firmware.c file_hex.c file_ic.c file_log.c files.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group middlewave/crc
    ../../src/middlewave/crc/: crc4_soft.c crc32_soft.c crc64_soft.c
  group middlewave/emwin/config
    ../../src/middlewave/emWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c SIMConf.c
  group middlewave/emwin/lib
    ../../src/middlewave/emWin/Lib/: STemWin540_CM4_OS_Keil_ot.lib
  group middlewave/gui
    ../../src/middlewave/gui/: WelcomeDLG.c
  group middlewave/OS
    ../../src/middlewave/emWin/OS/: GUI_X_OS.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.11.0, File System:Drive:NOR 6.11.0, CMSIS Driver:SPI 2.11, CMSIS Driver:USB Device:Full-speed 2.19, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:CRC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DAC 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:Flash 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:PCD 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:Startup 2.6.2
