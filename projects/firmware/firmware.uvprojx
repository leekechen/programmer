# Keil uVision project firmware.uvprojx, settings and files
target Flash_0x08020000 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  AfterMake: fromelf.exe  --bin -o ..\..\bin\firmware.bin Objects\firmware.axf
  AfterMake: ..\..\tools\cspack\cspack.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HAVE_BOOTLOADER OS_SUPPORT
  c include: ..\..\src\common;..\..\src\firmware;..\..\src\middlewave\program;..\..\src\middlewave\program\timing;..\..\src\middlewave\files;..\..\src\middlewave\protocol;..\..\src\middlewave\crc;..\..\src\middlewave\emWin\Config;..\..\src\middlewave\emWin\inc;..\..\src\middlewave\emWin\OS;..\..\src\drivers\bsp;..\..\src\drivers\dbg;..\..\src\drivers\spi_flash;..\..\src\drivers\usb;..\..\src\drivers\fram;..\..\src\drivers\lcd;..\..\src\drivers\power;.\RTE\USB;..\..\..\trunk;..\..\src\middlewave\gui;..\..\..\programmer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\firmware.sct
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group firmware
    ../../src/firmware/: firmware.c ui.c
  group common
    ../../src/common/: error.c cswrite_cfg.c tlv.c cswrite_log.c
  group middlewave/gui
    ../../src/middlewave/gui/: FramewinDLG.c ChipDLG.c ConfigDLG.c CSWriteDLG.c SummaryDLG.c HexDLG.c gui_main.c
  group middlewave/files
    ../../src/middlewave/files/: file_firmware.c file_hex.c files.c file_dev.c file_ic.c file_log.c file_cfg.c
  group middlewave/protocol
    ../../src/middlewave/protocol/: protcol.c
  group middlewave/program
    ../../src/middlewave/program/: program.c
  group middlewave/program/chipsea
    ../../src/middlewave/program/chips/: CSU8RT30213.c CSU8RP3228.c
  group middlewave/program/timing
    ../../src/middlewave/program/timing/: io_icsp.c io_spi.c
  group middlewave/crc
    ../../src/middlewave/crc/: crc4_soft.c crc32_soft.c crc64_soft.c
  group middlewave/emWin/config
    ../../src/middlewave/emWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c SIMConf.c
  group middlewave/emWin/Lib
    ../../src/middlewave/emWin/Lib/: STemWin540_CM4_OS_Keil.lib
  group middlewave/emWin/OS
    ../../src/middlewave/emWin/OS/: GUI_X_OS.c
  group drivers/bsp
    ../../src/drivers/bsp/: crc32.c embed_flash.c retarget.c i2c_sw.c key.c buzzer.c led.c vs.c delay.c stm32f4xx_ll_gpio.c
  group drivers/power
    ../../src/drivers/power/: power.c
  group drivers/spi_flash
    ../../src/drivers/spi_flash/: w25qxx.c spi_flash.c
  group drivers/fram
    ../../src/drivers/fram/: mb85rcxx.c fram_map.c
  group drivers/usb
    ../../src/drivers/usb/: hid.c
  group drivers/dbg
    ../../src/drivers/dbg/: dbg_print.c
  group drivers/lcd
    ../../src/drivers/lcd/: st7789v.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, File System:CORE 6.11.0, File System:Drive:NOR 6.11.0, USB:CORE 6.13.0, USB:Device 6.13.0, USB:Device:HID 6.13.0, CMSIS Driver:SPI 2.11, CMSIS Driver:USB Device:Full-speed 2.19, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:CRC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DAC 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:Flash 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:PCD 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:Startup 2.6.2
