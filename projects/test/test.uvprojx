# Keil uVision project test.uvprojx, settings and files
target Flash_0x08040000 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\src\common;..\..\src\drivers\bsp;..\..\src\drivers\dbg;..\..\src\drivers\fram;..\..\src\drivers\lcd;..\..\src\drivers\power;..\..\src\drivers\spi_flash;..\..\src\drivers\usb;..\..\src\test;..\..\src\test\hardware;..\..\src\test\function;..\..\src\test\limation;..\..\src\test\performance;.\RTE\USB;..\..\src\middlewave\files;..\..\src\middlewave\program\timing;..\..\src\middlewave\program;..\..\..\trunk;..\..\src\middlewave\crc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group test
    ../../src/test/: test.c
  group test/hardware
    ../../src/test/hardware/: test_buzzer.c test_extension_interface.c test_fram.c test_hardware.c test_key.c test_lcd.c test_led.c test_power.c test_program_interface.c test_spi_flash.c test_temperature_cali_interface.c test_usb.c test_vs.c test_collection.c
  group test/function
    ../../src/test/function/: test_crc32.c test_function.c test_file.c
  group test/limation
    ../../src/test/limation/: test_limation.c
  group test/performance
    ../../src/test/performance/: test_performance.c
  group common
    ../../src/common/: error.c cswrite_cfg.c tlv.c cswrite_log.c
  group middlewave/program
    ../../src/middlewave/program/: program.c
  group middlewave/program/timing
    ../../src/middlewave/program/timing/: io_icsp.c io_spi.c
  group middlewave/files
    ../../src/middlewave/files/: file_firmware.c file_hex.c files.c file_cfg.c file_dev.c file_ic.c file_log.c
  group middlewave/protocol
    ../../src/middlewave/protocol/: protcol.c
  group drivers/bsp
    ../../src/drivers/bsp/: buzzer.c crc32.c delay.c embed_flash.c i2c_sw.c key.c led.c retarget.c stm32f4xx_ll_gpio.c vs.c
  group drivers/dbg
    ../../src/drivers/dbg/: dbg_print.c
  group drivers/fram
    ../../src/drivers/fram/: mb85rcxx.c fram_map.c
  group drivers/lcd
    ../../src/drivers/lcd/: lcd.c
  group drivers/power
    ../../src/drivers/power/: power.c
  group drivers/spi_flash
    ../../src/drivers/spi_flash/: spi_flash.c w25qxx.c
  group drivers/usb
    ../../src/drivers/usb/: hid.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group middlewave/program/chipsea
    ../../src/middlewave/program/chips/: CSU8RP3228.c
    ../../src/middlewave/crc/: crc4_soft.c crc32_soft.c crc64_soft.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, File System:CORE 6.11.0, File System:Drive:NOR 6.11.0, USB:CORE 6.13.0, USB:Device 6.13.0, USB:Device:HID 6.13.0, CMSIS Driver:SPI 2.11, CMSIS Driver:USB Device:Full-speed 2.19, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:CRC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DAC 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:Flash 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:PCD 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:Startup 2.6.2
